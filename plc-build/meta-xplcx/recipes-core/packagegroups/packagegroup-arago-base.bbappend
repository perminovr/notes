
PR_append = "-e"

ARAGO_ALSA_BASE_remove = "\
    alsa-lib \
    alsa-utils-aplay \
    "

ARAGO_BASE_remove = " \
    curl \
    initscript-telnetd \
    "
