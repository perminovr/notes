SHARED_EXTRA_OECONF += " \
                       --disable-schedutils \
"

